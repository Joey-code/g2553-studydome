<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x72eC;&#x7ACB;&#x6309;&#x952e;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


