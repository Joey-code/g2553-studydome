<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x770B;&#x95e8;&#x72D7;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


