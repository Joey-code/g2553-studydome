<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x77e9;&#x9635;&#x952e;&#x76D8;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


